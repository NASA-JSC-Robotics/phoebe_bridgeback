Commit message: not running environment for RSP

File: phoebe_mujoco_config/urdf/phoebe_mujoco_xacro.urdf (robot description, URDF)
Before this commit: robot phoebe, 1 links, 1 joints
Joints:
- joint floating_base_joint: type floating -> $(arg base_joint_type)
